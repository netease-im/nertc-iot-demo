## beken/nertc_host/components/nertc_sdk/Kconfig
```kconfig
menu "Bk_thirdparty::nertc_sdk"

	config NERTC_SDK
		bool "Enable nertc sdk"
		default n
		help
			Enable nertc sdk lib

endmenu
```
